# Keil uVision project project.uvprojx, settings and files
target ACM32P4XX (6210000::V6.21::ARMCLANG)
  device: ACM32P4XX Aisinochip
  pack: Aisinochip.ACM32P4XX.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08002000,0x000FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: ACM32P4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/ACM32P4XX.bin ./build/ACM32P4XX.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\utest;libraries\acm32p4\include\hardware;..\..\..\components\drivers\include;applications;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\cortex-m33;libraries\acm32p4\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;drivers;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\phy;.;..\..\..\components\drivers\smp_call;libraries\acm32p4\include\device;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\compilers\common\extension
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group ACM32P4_SDK
    libraries/acm32p4/src/: adc.c assert.c clocks.c comp.c crc.c dac.c dlyb.c dma.c eth.c exti.c fdcan.c gpio.c i2c.c i2s.c iwdt.c lptim.c lpuart.c ospi.c pmu.c rtc.c sdmmc.c spi.c syscfg.c system.c tim.c tim64b.c uart.c usb.c wdt.c
    libraries/acm32p4/startup/: system_acm32p4xx.c startup_acm32p4xx.s
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
software components: CMSIS:CORE 6.2.0
