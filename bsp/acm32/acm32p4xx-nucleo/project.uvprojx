# Keil uVision project project.uvprojx, settings and files
target ACM32P4XX (6210000::V6.21::ARMCLANG)
  device: ACM32P4XX Aisinochip
  pack: Aisinochip.ACM32P4XX.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08002000,0x000FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: ACM32P4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/keil/ACM32P4XX.bin ./build/keil/ACM32P4XX.axf
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3
  c define: MEM_LIBC_MALLOC=1, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, MEMP_NUM_TCPIP_MSG_INPKT=16, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\..\..\components\net\lwip\port;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\ipc;..\..\..\components\net\utest;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\libc\posix\io\poll;..\..\..\components\net\lwip\lwip-2.1.2\src\include\compat\posix;..\..\..\components\drivers\include;libraries\Device;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include;libraries\CMSIS;..\..\..\components\drivers\include;..\..\..\components\finsh;.;libraries\HAL_Driver\Inc;..\..\..\components\drivers\spi;..\..\..\components\net\netdev\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;drivers;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\lwip\port;applications
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\drivers\linker_scripts\acm32p4xx.sct
  group ACM32_HAL
    libraries/Device/: system_acm32p4xx.c system_accelerate.c
    libraries/HAL_Driver/Src/: hal.c hal_cortex.c hal_rcc.c hal_gpio.c hal_exti.c hal_dma.c hal_uart.c hal_usart.c hal_lpuart.c hal_pmu.c hal_efuse.c hal_eth.c hal_spi.c hal_adc.c hal_dac.c hal_i2c.c hal_fdcan.c hal_rtc.c hal_wdt.c hal_iwdt.c hal_sdmmc.c hal_i2s.c hal_lptim.c hal_timer.c hal_hrng.c
    libraries/Device/ARM/: startup_acm32p4xx.s
  group Applications
    applications/: adc_test.c can_test.c cap_test.c dac_test.c enc_test.c eth_test.c hw_test.c i2c_test.c lptim_test.c main.c psram_test.c pwm_test.c rtc_test.c spi_test.c timer_test.c uart_test.c wdt_test.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    drivers/: board.c drv_adc.c drv_can.c drv_crypto.c drv_dac.c drv_eth.c drv_gpio.c drv_i2c.c drv_i2s.c drv_inputcapture.c drv_lptimer.c drv_pulse_encoder.c drv_pwm.c drv_rtc.c drv_sdmmc.c drv_spi.c drv_tim_utils.c drv_timer.c drv_uart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
software components: CMSIS:CORE 6.2.0
