# Keil uVision project template.uvprojx, settings and files
target ACM32P4XX (6210000::V6.21::ARMCLANG)
  device: ACM32P4XX Aisinochip
  pack: Aisinochip.ACM32P4XX.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08002000,0x000FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: ACM32P4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/keil/ACM32P4XX.bin ./build/keil/ACM32P4XX.axf
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\lwip\port
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\drivers\linker_scripts\acm32p4xx.sct
software components: CMSIS:CORE 6.2.0
